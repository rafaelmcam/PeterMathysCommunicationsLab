options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E3B
    output_language: python
    title: E3B
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: FB * sps
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: '[5, 0.5]'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: '[5, 0]'
  states: {state: disabled}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: rrcf
    label1: tri
    label2: '"rcf"'
    num_opts: '3'
    option1: '"tri"'
    option2: '"rcf"'
    orient: Qt.QHBoxLayout
    type: string
    value: '"rrcf"'
    widget: radio_buttons
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: 2 * sps
    value: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sym_dly
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: 2 * sps
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sym_dly
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: samp_dly
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/4
    type: byte
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: FB
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in 'The quick brown fox...\n')
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pamhRt(sps, ptype, pparms)
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from ModuleLab6 import pamhRt
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pampt(sps, ptype, pparms)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: fff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    decim: '1'
    gain: '1'
    samp_rate: FB
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Power"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: FB
    fc: '0'
    fftsize: '1024'
    gui_hint: 2, 0, 4, 1
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2, 1, 4, 1
    marker2: '0'
    nconnections: '2'
    size: 1024 // 4
    srate: Fs
    style2: '0'
    type: float
    ymax: '1.3'
    ymin: '-1.3'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_delay_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_complex_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0_0, '0']
- [fir_filter_xxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_float_to_complex_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_time_sink_x_1, '1']
- [low_pass_filter_0_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
