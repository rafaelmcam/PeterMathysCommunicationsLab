options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: T2
    output_language: python
    title: T2
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: FB * sps
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: '[5, 0.5]'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    label0: rect
    label1: rcf
    label2: rrcf
    num_opts: '3'
    option1: '"rcf"'
    option2: '"rrcf"'
    orient: Qt.QHBoxLayout
    type: string
    value: '"rect"'
    widget: radio_buttons
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: 2 * sps
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sym_dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: 2 * sps
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sym_dly
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: samp_dly
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/5
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: FB
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in 'The quick brown fox...\n')
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pamhRt(sps, ptype, pparms)
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from ModuleLab6 import pamhRt
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pampt(sps, ptype, pparms)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    name: '"Mid"'
    size: 1024 // 4
    srate: Fs
    stemplot: 'True'
    style1: '2'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 1024 // 4
    srate: Fs
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"BlaBla"'
    size: '1024'
    srate: FB
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_delay_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0_0, '0']
- [fir_filter_xxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_1, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_2, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
