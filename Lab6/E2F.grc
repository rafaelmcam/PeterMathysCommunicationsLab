options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E2F
    output_language: python
    title: E2F
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: FB * sps
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: '[5, 0.5]'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    label0: rrcf
    label1: rect
    label2: '"man"'
    label3: tri
    num_opts: '4'
    option1: '"rect"'
    option2: '"man"'
    option3: '"tri"'
    orient: Qt.QHBoxLayout
    type: string
    value: '"rrcf"'
    widget: radio_buttons
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sym_dly
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: 2 * sps
    value: '0'
  states: {}
- name: tlbw
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '0.2'
    value: '62.8e-3'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sym_dly
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/0
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: FB * 4
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in 'The quick brown fox...\n')
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts / 2
    loop_bw: tlbw
    max_dev: '0.7'
    osps: '1'
    sps: sps
    taps: 1/float(sps) * pampt(sps * nfilts, ptype, pparms)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from ModuleLab6 import pampt
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from ModuleLab6 import pamhRt
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pampt(sps, ptype, pparms)
    type: fff
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: FB
    fc: '0'
    fftsize: '1024'
    gui_hint: 2, 0, 4, 1
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 2, 1, 4, 1
    nconnections: '3'
    size: '1024'
    srate: FB * sps
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_0, '2']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
