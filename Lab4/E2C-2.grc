options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E2C2
    output_language: python
    title: E2C-2
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '100'
  states: {}
- name: N
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 2
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '10'
    value: '2'
  states: {}
- name: fL
  id: variable
  parameters:
    value: FB * factor
  states: {}
- name: fL_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '20'
    step: '10'
    stop: '1000'
    value: FB
  states: {state: disabled}
- name: factor
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: f"pamsig403_part2_rcv_N_{N}_dot{str(factor).split('.')[-1]}.wav"
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Files/pamsig403.wav
    repeat: 'False'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: butter(N, 2 * fL/float(samp_rate))[1]
    fftaps: butter(N, 2 * fL/float(samp_rate))[0]
    oldstyle: 'False'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from scipy.signal import butter
  states: {}
- name: note_0
  id: note
  parameters:
    note: Não usar old style para definição dos taps
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2, 0, 5, 2
    size: 1024 * 2
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle_0, '0', iir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [iir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
