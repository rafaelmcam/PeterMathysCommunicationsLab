options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E3D
    output_language: python
    title: E3D
  states: {}

blocks:
- name: beta
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: dly
  id: variable
  parameters:
    value: '320'
  states: {}
- name: dly
  id: variable
  parameters:
    value: '30'
  states: {state: disabled}
- name: k
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    label: 'Select PAM pulse: p(t)'
    label0: rect
    label1: sinc
    label2: tri
    num_opts: '3'
    option1: sinc
    option2: tri
    type: string
    value: rect
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: dly
    type: float
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 5
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rcampello/Main/3m/Simulação de sistemas de comunicação/Labs/Lab4/pamsig403_part2_rcv_N_1_dot5.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rcampello/Main/3m/Simulação de sistemas de comunicação/Labs/Lab4/pamsig403_rcv_dot2.wav
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ptfun as pf
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: dly
    taps: pf.pampt(sps, ptype, [k, beta])
    type: fff
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: Use o dly 320 se for importar o wavfile, dly 30 caso seja a fonte random source
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color10: blue
    color2: blue
    color3: blue
    color4: blue
    color5: blue
    color6: blue
    color7: blue
    color8: blue
    color9: blue
    grid: 'True'
    nconnections: '10'
    size: dly  * 3
    srate: samp_rate
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '8']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '9']
- [blocks_int_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
