options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E1D
    output_language: python
    title: E1D
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: fL_div_by_FB
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 2
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: sps / 2
    value: '0.5'
  states: {}
- name: pparams
  id: variable
  parameters:
    value: '[10, 0.2]'
  states: {}
- name: ptype
  id: variable
  parameters:
    value: '"man"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '22'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from ModuleLab5 import pampt
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pampt(sps, ptype, pparams)
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fL_div_by_FB * FB
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: fL_div_by_FB * FB / 20
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1, 2, 2, 2
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0, 2, 1, 1
    label1: Power
    max: '2'
    min: '0'
    name: '"Absolute Power"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0, 3, 1, 1
    label1: '%'
    min: '0'
    name: '"Porcentagem da Energia"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1, 0, 2, 2
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_divide_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0_0, '1']
- [interp_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', blocks_divide_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_number_sink_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
