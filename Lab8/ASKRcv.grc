options:
  parameters:
    author: rcampello
    category: '[Lab8]'
    generate_options: hb
    id: ASKrcvr_cb
    output_language: python
    title: ASK Rcvr
  states: {}

blocks:
- name: MF0_cc_0
  id: MF0_cc
  parameters:
    a_gain: a_gain
    b_FB: b_FB
    c_sps: e_sps
    d_ptype: f_ptype
    e_pparms: g_pparms
    f_fcparms: h_fcparms
    g_samp_dly: j_samp_dly
  states: {}
- name: Y2B_fb_0
  id: Y2B_fb
  parameters:
    a_gain: float(np.real(i_IQgain))
    b_bpsym: int(np.real(c_bpsym))
    c_pol: '0'
    d_sym_dly: int(np.real(k_sym_dly))
  states: {}
- name: Y2B_fb_0_0
  id: Y2B_fb
  parameters:
    a_gain: float(np.real(i_IQgain))
    b_bpsym: int(np.real(c_bpsym))
    c_pol: d_pol
    d_sym_dly: int(np.real(k_sym_dly))
  states: {}
- name: Y2B_fb_0_1
  id: Y2B_fb
  parameters:
    a_gain: float(np.imag(i_IQgain))
    b_bpsym: int(np.imag(c_bpsym))
    c_pol: d_pol
    d_sym_dly: int(np.imag(k_sym_dly))
  states: {}
- name: a_gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1'
  states: {}
- name: b_FB
  id: parameter
  parameters:
    label: Baud Rate
    type: intx
    value: '32000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: c_bpsym
  id: parameter
  parameters:
    label: Bits per Symbol
    type: complex
    value: 1 + 1j
  states: {}
- name: d_pol
  id: parameter
  parameters:
    label: Polar
    type: intx
    value: '0'
  states: {}
- name: e_sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '8'
  states: {}
- name: f_ptype
  id: parameter
  parameters:
    label: Pulse Type
    type: str
    value: '"rect"'
  states: {}
- name: g_pparms
  id: parameter
  parameters:
    label: Pulse Params
    value: (5, 0.3)
  states: {}
- name: h_fcparms
  id: parameter
  parameters:
    label: fc Params
    value: (32000, 0)
  states: {}
- name: i_IQgain
  id: parameter
  parameters:
    label: IQ Gain
    type: complex
    value: 1 + 1j
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: j_samp_dly
  id: parameter
  parameters:
    label: Sample Delay
    type: intx
    value: '0'
  states: {}
- name: k_sym_dly
  id: parameter
  parameters:
    label: Symbol Delay
    type: complex
    value: '0'
  states: {}
- name: mfzerocc_0
  id: mfzerocc
  parameters:
    a_gain: a_gain
    b_FB: b_FB
    c_sps: e_sps
    d_ptype: f_ptype
    e_pparms: g_pparms
    f_fcparms: h_fcparms
    g_samp_dly: j_samp_dly
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: MF out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: Samples out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Env-Data out
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: I-Data out
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: Q-Data out
    optional: 'True'
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [MF0_cc_0, '0', pad_sink_0, '0']
- [MF0_cc_0, '1', blocks_complex_to_float_0, '0']
- [MF0_cc_0, '1', blocks_complex_to_mag_0, '0']
- [MF0_cc_0, '1', pad_sink_1_0, '0']
- [MF0_cc_0, '2', pad_sink_1, '0']
- [Y2B_fb_0, '0', pad_sink_2, '0']
- [Y2B_fb_0_0, '0', pad_sink_3, '0']
- [Y2B_fb_0_1, '0', pad_sink_3_0, '0']
- [blocks_complex_to_float_0, '0', Y2B_fb_0_0, '0']
- [blocks_complex_to_float_0, '1', Y2B_fb_0_1, '0']
- [blocks_complex_to_mag_0, '0', Y2B_fb_0, '0']
- [mfzerocc_0, '0', pad_sink_0, '0']
- [mfzerocc_0, '1', blocks_complex_to_float_0, '0']
- [mfzerocc_0, '1', blocks_complex_to_mag_0, '0']
- [mfzerocc_0, '1', pad_sink_1_0, '0']
- [mfzerocc_0, '2', pad_sink_1, '0']
- [pad_source_0, '0', MF0_cc_0, '0']
- [pad_source_0, '0', mfzerocc_0, '0']

metadata:
  file_format: 1
