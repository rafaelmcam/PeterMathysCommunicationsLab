options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E3D
    output_language: python
    title: E3D
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: sps * FB
  states: {}
- name: I_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: Q_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: bpsym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc_Xmtr
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-300000'
    step: '0.1'
    stop: '300000'
    value: '235000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '4'
    value: '1'
  states: {}
- name: pol
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '1'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: (5, 0.3)
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    label0: rect
    label1: tri
    label2: rcf
    label3: rrcf
    num_opts: '4'
    option0: rect
    option1: tri
    option2: rcf
    option3: rrcf
    type: string
    value: rect
    widget: radio_buttons
  states: {state: disabled}
- name: ptype
  id: variable
  parameters:
    value: '"rect"'
  states: {state: disabled}
- name: ptype
  id: variable
  parameters:
    value: '"rect"'
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '32'
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '80'
  states: {}
- name: sym_dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '16'
    value: '0'
  states: {}
- name: tag0
  id: variable_tag_object
  parameters:
    key: pmt.intern("T")
    offset: '0'
    src: pmt.intern("vec src")
    value: pmt.intern("0x54")
  states: {}
- name: thc_Xmtr
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: ASKrcvr_cb_0
  id: ASKrcvr_cb
  parameters:
    a_gain: gain
    b_FB: FB
    c_bpsym: bpsym * (1 + 1j)
    d_pol: pol
    e_sps: sps
    f_ptype: ptype
    g_pparms: pparms
    h_fcparms: (fc_Xmtr, thc_Xmtr)
    i_IQgain: I_gain + 1j * Q_gain
    j_samp_dly: samp_dly
    k_sym_dly: sym_dly
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/7
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/6
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/7
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /dev/pts/8
    type: byte
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/9
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rcampello/Main/3m/Simulação de sistemas de comunicação/Labs/Lab8/Files/digMod_805.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Fs
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Fs
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Fs
    fc: '0'
    fftsize: '1024'
    name: '"After"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ASK Xmtr"'
    size: '1024'
    srate: Fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"MF/Sample Out"'
    nconnections: '2'
    size: '1024'
    srate: Fs
    type: complex
  states: {}

connections:
- [ASKrcvr_cb_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ASKrcvr_cb_0, '0', qtgui_time_sink_x_1, '0']
- [ASKrcvr_cb_0, '1', qtgui_time_sink_x_1, '1']
- [ASKrcvr_cb_0, '2', qtgui_const_sink_x_0, '0']
- [ASKrcvr_cb_0, '3', blocks_file_sink_0, '0']
- [ASKrcvr_cb_0, '3', blocks_null_sink_0_1, '0']
- [ASKrcvr_cb_0, '4', blocks_file_sink_0_0, '0']
- [ASKrcvr_cb_0, '4', blocks_file_sink_0_1, '0']
- [ASKrcvr_cb_0, '4', blocks_null_sink_0, '0']
- [ASKrcvr_cb_0, '5', blocks_file_sink_0_0_0, '0']
- [ASKrcvr_cb_0, '5', blocks_file_sink_0_1_0, '0']
- [ASKrcvr_cb_0, '5', blocks_null_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ASKrcvr_cb_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
