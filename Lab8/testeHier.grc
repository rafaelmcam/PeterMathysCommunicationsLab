options:
  parameters:
    author: rcampello
    generate_options: hb
    id: testeHier
    output_language: python
    title: testeHier
  states: {}

blocks:
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: th
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: th
  id: parameter
  parameters:
    label: th
    type: intx
    value: '32000'
  states: {}

connections:
- [blocks_throttle_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
