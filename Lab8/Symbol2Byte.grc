options:
  parameters:
    author: rcampello
    category: '[Lab8]'
    generate_options: hb
    id: Y2B_fb
    output_language: python
    title: Symbol to Byte
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2 ** b_bpsym
  states: {}
- name: a_gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1'
  states: {}
- name: b_bpsym
  id: parameter
  parameters:
    label: Bits per symbol
    type: intx
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: M - 1 if c_pol else 0
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d_sym_dly
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.5 if c_pol else 1
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: b_bpsym
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: c_pol
  id: parameter
  parameters:
    label: Polar
    type: intx
    value: '0'
  states: {}
- name: d_sym_dly
  id: parameter
  parameters:
    label: Symbol Delay
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
