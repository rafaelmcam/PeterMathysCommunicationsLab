options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: teste
    output_language: python
    title: teste
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: bpsym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: pol
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '1'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: pparms
  id: variable
  parameters:
    value: (5, 0.3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ASKxmtr_bc_0
  id: ASKxmtr_bc
  parameters:
    a_FB: FB
    b_bpsym: bpsym
    c_pol: pol
    d_sps: sps
    e_ptype: ptype
    f_pparms: pparms
    g_fcparms: (fc_Xmtr, thc_Xmtr)
  states: {state: disabled}
- name: MF0_cc_0
  id: MF0_cc
  parameters: {}
  states: {state: disabled}
- name: MF0_cc_1
  id: MF0_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: FB
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0, 0, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in "The quick brown fox...\n")
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: list(ord(i) for i in "The quick brown fox...\n")
  states: {}
- name: mfzerocc_0
  id: mfzerocc
  parameters:
    a_gain: '1'
    b_FB: '32000'
    c_sps: '8'
    d_ptype: '"rect"'
    e_pparms: (5, 0.3)
    f_fcparms: (32000, 0)
    g_samp_dly: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: Fs
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ASKxmtr_bc_0, '0', MF0_cc_0, '0']
- [ASKxmtr_bc_0, '0', blocks_throttle_0_0, '0']
- [MF0_cc_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0_0, '0', MF0_cc_1, '0']
- [blocks_throttle_0_0, '0', mfzerocc_0, '0']
- [blocks_vector_source_x_1, '0', blocks_throttle_0_0, '0']
- [mfzerocc_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
