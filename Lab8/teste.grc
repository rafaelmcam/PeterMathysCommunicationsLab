options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: teste
    output_language: python
    title: teste
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: bpsym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: pol
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '1'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {state: disabled}
- name: pparms
  id: variable
  parameters:
    value: (5, 0.3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ASKxmtr_bc_0
  id: ASKxmtr_bc
  parameters:
    a_FB: FB
    b_bpsym: bpsym
    c_pol: pol
    d_sps: sps
    e_ptype: ptype
    f_pparms: pparms
    g_fcparms: (fc_Xmtr, thc_Xmtr)
  states: {state: disabled}
- name: ASKxmtr_bc_0_0
  id: ASKxmtr_bc
  parameters:
    a_FB: '32000'
    b_bpsym: '1'
    c_pol: '1'
    d_sps: '16'
    e_ptype: '"rect"'
    f_pparms: '[5, 0.3]'
    g_fcparms: (50000, 0)
  states: {}
- name: MF0_cc_0
  id: MF0_cc
  parameters: {}
  states: {state: disabled}
- name: MF0_cc_1
  id: MF0_cc
  parameters: {}
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: dly
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/5
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: Fs
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0, 0, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in "The quick brown fox...\n")
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in "The quick brown fox...\n")
  states: {}
- name: mfzerocc_0
  id: mfzerocc
  parameters:
    a_gain: gain
    b_FB: '32000'
    c_sps: '16'
    d_ptype: '"rect"'
    e_pparms: '[5, 0.3]'
    f_fcparms: '[50000, 0]'
    g_samp_dly: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: Fs
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: Fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"MF/Sample Out"'
    nconnections: '2'
    size: '1024'
    srate: Fs
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Final"'
    size: '1024'
    srate: Fs
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Probe"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ASKxmtr_bc_0, '0', MF0_cc_0, '0']
- [ASKxmtr_bc_0_0, '0', blocks_throttle_0_1, '0']
- [ASKxmtr_bc_0_0, '0', mfzerocc_0, '0']
- [ASKxmtr_bc_0_0, '0', qtgui_time_sink_x_2_1_0, '0']
- [MF0_cc_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_throttle_0_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0_1, '0', ASKxmtr_bc_0_0, '0']
- [mfzerocc_0, '0', qtgui_time_sink_x_1_0, '0']
- [mfzerocc_0, '1', blocks_complex_to_mag_0, '0']
- [mfzerocc_0, '1', qtgui_const_sink_x_0, '0']
- [mfzerocc_0, '2', qtgui_time_sink_x_1_0, '1']

metadata:
  file_format: 1
