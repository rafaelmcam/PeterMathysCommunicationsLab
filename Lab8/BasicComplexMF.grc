options:
  parameters:
    author: rcampello
    category: '[Lab8]'
    generate_options: qt_gui
    id: MF0_cc
    output_language: python
    title: Basic Complex MF
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: a_gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1'
  states: {}
- name: b_FB
  id: parameter
  parameters:
    label: Baud Rate
    type: intx
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0)
  states: {}
- name: c_sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '8'
  states: {}
- name: d_ptype
  id: parameter
  parameters:
    label: Pulse Type
    type: str
    value: '"rectd"'
  states: {}
- name: e_pparms
  id: parameter
  parameters:
    label: Pulse Params
    value: (5, 0.3)
  states: {}
- name: f_fcparms
  id: parameter
  parameters:
    label: (32000, 0)
    value: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: ModuleLab6.pamhRt(8, "rect", [])
    type: ccc
  states: {}
- name: g_samp_dly
  id: parameter
  parameters:
    label: Sample Delay
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import ModuleLab6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import sys
      from inspect import getmembers, isfunction

      print(sys.path)

      print(getmembers(ModuleLab6, isfunction))


      print(ModuleLab6)
    priority: ''
    section: main_after_init
  states: {}

connections:
- [blocks_vector_source_x_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
