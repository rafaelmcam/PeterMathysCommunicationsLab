options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: e1f
    output_language: python
    title: e1f
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: Fs/sps
  states: {}
- name: Fs
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: G
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: bpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[-1, 1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '315000000'
  states: {}
- name: fc_MHz
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    orient: Qt.Horizontal
    start: '300'
    step: '0.001'
    stop: '330'
    value: '315'
  states: {state: disabled}
- name: fe
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '256'
    value: '8'
  states: {state: disabled}
- name: sym_dly
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '16'
    value: '7'
  states: {}
- name: theta1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1, 1, 1, 1
    label0: '-90'
    label1: '0'
    label2: '90'
    label3: '180'
    num_opts: '4'
    option0: '-90'
    option1: '0'
    option2: '90'
    option3: '180'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: theta2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fe
    offset: '0'
    phase: '0'
    samp_rate: Fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sym_dly
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/5
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rcampello/Main/3m/Simulação de sistemas de comunicação/Labs/Lab8/Files/lab08_multi_rcvr_001f_rec001.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: G * np.exp(1j * np.pi * (theta1 + theta2) / 180)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Fs
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_const
    fmax: '100'
    fmin: '-100'
    loop_bw: '0.0625'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.06'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(32, 32, 1/sps, 0.35, 45 * 32)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3, 0, 1, 1
    nconnections: '2'
    size: '256'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: Fs
    fc: '315000000'
    fftsize: '1024'
    name: '"File Input"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4, 0, 1, 1
    label1: Re{Data 0}
    label2: Im{Data 0}
    label3: Re{Data 1}
    label4: Im{Data 1}
    name: '"PAM Xmtr"'
    nconnections: '2'
    size: '256'
    srate: Fs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3, 1, 1, 1
    label1: Re{Data 0}
    label2: Im{Data 0}
    marker1: '0'
    name: '"RCV Sampled"'
    size: '64'
    srate: FB
    stemplot: 'True'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4, 1, 1, 1
    label1: Error
    label2: Phase
    label3: Freq
    marker1: '0'
    marker2: '0'
    marker3: '0'
    name: '"PAM Rcvr"'
    nconnections: '3'
    size: '64'
    srate: Fs
    stemplot: 'True'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_delay_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_delay_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', qtgui_time_sink_x_1, '0']
- [digital_constellation_receiver_cb_0, '2', qtgui_time_sink_x_1, '1']
- [digital_constellation_receiver_cb_0, '3', qtgui_time_sink_x_1, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_delay_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
