options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E3C
    output_language: python
    title: E3C
  states: {}

blocks:
- name: f1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '5000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tag1
  id: variable_tag_object
  parameters:
    key: pmt.intern("t0")
    offset: '0'
    src: pmt.intern("VecSrc")
    value: pmt.intern("0")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag1]'
    type: float
    vector: generate_signal_E3C(samp_rate, f1)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from ModuleLab3 import generate_signal_E3C
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024 // 4
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: 1024 // 4
    srate: samp_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
