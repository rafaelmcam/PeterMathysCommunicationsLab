options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: E2C
    output_language: python
    title: E2C
  states: {}

blocks:
- name: beta
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: k
  id: variable
  parameters:
    value: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 1, 1, 1
    label: 'Select PAM pulse: p(t)'
    label0: rect
    label1: sinc
    label2: tri
    num_opts: '3'
    option1: sinc
    option2: tri
    type: string
    value: rect
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e3)
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    orient: Qt.Horizontal
    rangeType: int
    start: '2'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.hstack((np.zeros(k), 1, np.zeros(k)))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import ptfun
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: ptfun.pampt(sps, ptype, [k, beta])
    type: fff
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate * sps
    fc: '0'
    fftsize: '1024'
    gui_hint: 0, 2, 3, 2
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1, 0, 2, 2
    marker1: '0'
    size: 1024 // 4
    srate: samp_rate * sps
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}

connections:
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
